options:
  parameters:
    author: Noorquacker
    generate_options: no_gui
    id: radiowhisper_demod
    output_language: python
    run_options: run
    title: RadioWhisper Demod
  states: {}

blocks:
- name: ctcssLevel
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: manualSquelch
  id: variable
  parameters:
    value: '-55'
  states: {}
- name: rfFreq
  id: variable
  parameters:
    value: '444525000'
  states: {}
- name: rfGain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2048e3
  states: {}
- name: volume
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_ctcss_squelch_ff_0
  id: analog_ctcss_squelch_ff
  parameters:
    freq: '162.2'
    gate: 'True'
    len: '0'
    level: ctcssLevel
    ramp: '0'
    rate: '48000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: manualSquelch
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '250'
    decim: '3'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '50'
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: '192000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_BLACKMAN
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1400'
    port: '2000'
    send_eof: 'False'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: rfFreq
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_ctcss_squelch_ff_0, '0', high_pass_filter_0, '0']
- [analog_nbfm_rx_0, '0', analog_ctcss_squelch_ff_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', network_udp_sink_0, '0']
- [high_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
